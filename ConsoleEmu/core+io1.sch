# EAGLE board core+io1 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$138  (via drill 0.61) (continued)
  Bottom 0.254: v121.28,52.54 v107.31,52.54 | v108.58,85.56 99.69,85.56 98.42,84.29 95.88,84.29 IC24.40
N$140
  Top 0.254: IC27.8 123.82,10.63 124.45,10.63 C4.1 125.09,11.27 126.36,12.54 126.36,16.98 123.19,20.15 IC27.12
  Bottom 0.254: R4.1 129.53,13.17 126.99,10.63 125.72,10.63 C4.1
N$141  (via drill 0.61)
  Top 0.254: R4.2 129.53,20.79 128.27,20.79 R3.1 127.63,21.42 v127.63,24.6
  Bottom 0.254: v127.63,24.6 123.82,24.6 123.19,23.96 IC27.13
N$142
  Bottom 0.254: IC27.11 123.82,18.25 132.07,18.25 C5.1
N$143
  Top 0.254: R10.1 114.3,5.55 113.02,6.82 113.02,7.46 R11.E
N$144
  Bottom 0.254: X1.4 89.53,20.15 90.16,19.52 95.24,19.52 95.88,18.88 X1.6
N$145
  Top 0.254: X1.8 91.44,18.25 92.7,18.25 X1.7
N$146
  Bottom 0.254: X1.G2 81.91,20.15 86.35,20.15 X1.5 86.99,21.42 87.62,22.06 100.32,22.06 102.23,20.15 X1.G1
N$147  (via drill 0.61)
  Top 0.254: IC18.13 153.03,20.15 153.03,18.88 IC18.12 | v123.82,60.16 123.82,51.27 125.72,49.37 125.72,48.09 126.36,47.46 129.53,47.46 130.17,48.09 131.44,48.09 131.44,46.82 130.81,46.19 130.81,35.39 v131.44,34.76 | v149.85,34.76 v149.85,20.79
  Bottom 0.254: v123.82,60.16 116.2,60.16 115.56,60.8 102.86,60.8 IC21.5 | v131.44,34.76 132.07,34.12 146.04,34.12 146.68,34.76 v149.85,34.76 | v149.85,20.79 151.76,20.79 IC18.13
N$148
  Top 0.254: IC18.11 154.3,15.71 154.94,15.71 LED1.K
N$149  (via drill 0.61)
  Top 0.254: v128.27,25.87 127.63,25.87 126.36,24.6 126.36,21.42 125.72,20.79 R12.1 | v157.47,25.87 158.11,25.23 158.11,16.34 LED1.A
  Bottom 0.254: v128.27,25.87 135.25,25.87 135.88,26.5 152.39,26.5 153.03,25.87 v157.47,25.87
N$150  (via drill 0.61)
  Top 0.254: v106.04,71.59 106.04,79.84 S2.B | v125.09,40.48 125.09,23.96 R13.2 | v113.66,42.38 113.02,43.02 113.02,67.14 113.66,67.78 v113.66,71.59
  Bottom 0.254: v106.04,71.59 v113.66,71.59 116.2,71.59 IC21.24 | v125.09,40.48 123.82,40.48 123.19,41.11 118.74,41.11 118.1,41.74 114.3,41.74 v113.66,42.38
N$151
  Top 0.254: IC28.4 151.12,110.33 152.39,111.59 152.39,117.94 146.68,123.66 113.66,123.66 113.66,103.97 114.3,103.34 114.3,74.77 109.21,69.69 109.21,40.48 108.58,39.84 108.58,24.6 107.31,23.33 107.31,21.42 107.94,20.79 107.94,10 107.31,9.36 107.31,7.46 113.02,1.74 151.76,1.74 151.76,8.09 IC18.8
N$152  (via drill 0.61)
  Top 0.254: v136.52,35.39 136.52,41.11 137.16,41.74 137.16,50 138.42,51.27 138.42,62.06 v137.79,62.7 | v155.57,62.7 155.57,76.67 154.94,77.3 154.94,90 155.57,90.64 v155.57,95.72
  Bottom 0.254: v136.52,35.39 137.16,34.76 145.41,34.76 146.04,35.39 147.31,35.39 IC19.5 | v155.57,62.7 v137.79,62.7 | v155.57,95.72 155.57,110.96 149.22,110.96 148.59,111.59 148.59,113.5 152.39,113.5 153.66,114.77 156.84,114.77 IC28.15
N$153
  Bottom 0.254: IC20.7 118.1,30.31 119.38,30.31 IC20.8
N$154
  Bottom 0.254: C7.1 109.85,25.23 112.39,22.7 113.02,22.7 114.3,21.42 IC27.3
N$155  (via drill 0.61)
  Top 0.254: v113.66,36.66 113.66,32.22 113.02,31.58 IC20.5 | v122.55,36.66 122.55,37.94 C9.2
  Bottom 0.254: v113.66,36.66 v122.55,36.66
N$156
  Bottom 0.254: IC20.4 110.48,31.58 112.39,33.49 121.91,33.49 C9.1
N$157  (via drill 0.61)
  Top 0.254: v106.67,36.03 106.67,31.58 IC20.3
  Bottom 0.254: v106.67,36.03 100.32,36.03 C8.2
N$158
  Top 0.254: C8.1 100.32,30.95 101.59,30.95 IC20.1
N$159
  Bottom 0.254: C11.1 110.48,28.41 111.12,29.04 113.02,29.04 114.3,30.31 IC20.6
N$160
  Bottom 0.254: C10.2 102.86,28.41 104.13,29.68 104.77,29.68 IC20.2
NMI\  (via drill 0.61)
  Top 0.254: v125.09,55.71 v125.09,71.59 125.09,73.5 R6.1
  Bottom 0.254: v125.09,55.71 119.38,55.71 118.74,55.08 116.2,55.08 115.56,55.71 102.86,55.71 IC21.7 | v125.09,71.59 126.36,71.59 IC17.6
OUT00  (via drill 0.61)
  Top 0.254: v26.03,86.19 26.03,82.39 IC1.1 | v19.68,86.19 19.68,102.7 20.31,103.34 20.31,117.94 v19.68,118.58 | v3.8,117.94 3.8,116.67 3.17,116.04 3.17,115.41 IC6.11
  Bottom 0.254: v19.68,86.19 v26.03,86.19 | v19.68,118.58 17.14,118.58 16.5,117.94 v3.8,117.94
OUT01  (via drill 0.61)
  Top 0.254: v8.25,77.94 v8.25,103.34
  Bottom 0.254: v8.25,77.94 22.22,77.94 22.86,78.58 25.39,78.58 IC1.2 | v8.25,103.34 1.9,103.34 1.27,103.97 1.27,110.96 6.98,110.96 9.52,113.5 12.06,113.5 13.33,114.77 14.6,114.77 IC7.11
OUT02
  Top 0.254: IC1.3 25.39,77.3 24.12,78.58 24.12,90 26.03,91.91 26.03,114.14 26.66,114.77 27.3,114.77 IC8.11
OUT03  (via drill 0.61)
  Top 0.254: v30.47,110.96 30.47,77.3 27.3,74.13 IC1.4
  Bottom 0.254: v30.47,110.96 33.02,113.5 37.46,113.5 38.73,114.77 40,114.77 IC10.11
OUT04  (via drill 0.61)
  Top 0.254: v38.1,70.32 v38.1,85.56 | v52.07,84.92 52.07,100.16 52.7,100.8 55.24,100.8 55.88,101.44 55.88,111.59 v56.51,112.23
  Bottom 0.254: v38.1,70.32 37.46,70.95 26.66,70.95 IC1.5 | v38.1,85.56 51.43,85.56 v52.07,84.92 | v56.51,112.23 54.61,114.14 IC11.11
OUT05  (via drill 0.61)
  Top 0.254: v31.11,69.05 31.11,102.7 33.02,104.61 33.02,105.25 32.38,105.88 32.38,114.77 v33.02,115.41 | v54.61,119.22 v54.61,116.67
  Bottom 0.254: v31.11,69.05 27.3,69.05 IC1.6 | v33.02,115.41 30.47,115.41 29.84,116.04 26.66,116.04 25.39,117.31 25.39,118.58 31.74,118.58 32.38,119.22 33.02,118.58 53.97,118.58 v54.61,119.22 | v54.61,116.67 57.78,113.5 62.86,113.5 64.13,114.77 65.4,114.77 IC12.11
OUT06  (via drill 0.61)
  Top 0.254: v38.73,66.51 39.37,67.14 39.37,70.32 38.73,70.95 38.73,84.92 39.37,85.56 v39.37,88.1 | v112.39,86.83 113.02,87.47 v113.02,103.34
  Bottom 0.254: v38.73,66.51 27.3,66.51 IC1.7 | v39.37,88.1 40,87.47 48.89,87.47 50.8,89.37 57.78,89.37 58.41,90 71.11,90 73.02,88.1 80.64,88.1 81.27,87.47 81.91,87.47 82.55,88.1 85.72,88.1 86.35,87.47 89.53,87.47 90.16,86.83 97.15,86.83 97.78,87.47 98.42,87.47 99.69,86.19 107.94,86.19 108.58,86.83 v112.39,86.83 | v113.02,103.34 106.04,103.34 101.59,107.78 101.59,110.96 98.42,110.96 97.15,112.23 97.15,114.14 96.52,114.14 94.61,116.04 90.8,116.04 88.26,113.5 85.72,113.5 85.08,114.14 82.55,114.14 81.91,114.77 80.64,114.77 IC13.11
OUT07  (via drill 0.61)
  Top 0.254: v89.53,112.23 89.53,110.96 88.89,110.33 v88.89,93.18 | v64.77,86.19 v64.77,93.18
  Bottom 0.254: v89.53,112.23 91.44,114.14 IC14.11 | v88.89,93.18 85.72,93.18 85.08,92.55 81.27,92.55 80.64,93.18 v64.77,93.18 | v64.77,86.19 64.13,85.56 59.05,85.56 57.78,84.29 52.7,84.29 52.07,83.66 50.8,84.92 38.73,84.92 38.1,84.29 20.31,84.29 19.04,83.02 2.54,83.02 1.27,81.75 1.27,65.24 22.22,65.24 23.49,63.97 24.76,63.97 IC1.8
PIA-A0  (via drill 0.61)
  Top 0.254: v69.21,96.99 69.21,90.64 69.84,90 69.84,79.84 70.48,79.21 IC25.18 | v14.6,80.48 14.6,79.21 15.24,78.58 15.24,41.74 13.97,40.48 13.97,37.94 14.6,37.3 IC3.2 | v9.52,80.48 8.89,81.11 8.89,96.36 9.52,96.99 IC6.3
  Bottom 0.254: IC2.2 3.8,36.66 6.98,36.66 7.62,36.03 12.06,36.03 13.33,37.3 14.6,37.3 IC3.2 17.14,37.3 19.68,37.3 20.95,36.03 24.76,36.03 26.03,37.3 27.3,37.3 IC4.2 29.84,37.3 32.38,37.3 33.65,36.03 37.46,36.03 38.73,37.3 40,37.3 IC9.2 42.54,37.3 45.08,37.3 45.72,36.66 46.98,36.66 47.62,36.03 52.7,36.03 53.34,36.66 IC15.2 55.24,37.3 56.51,37.3 57.15,36.66 59.69,36.66 60.32,36.03 65.4,36.03 66.03,36.66 IC16.2 | IC14.3 98.42,96.99 94.61,96.99 93.34,98.26 89.53,98.26 88.89,97.62 88.89,96.99 88.26,96.99 IC13.3 85.72,96.99 81.91,96.99 80.64,98.26 76.83,98.26 76.19,97.62 74.92,97.62 IC12.3 73.02,96.99 v69.21,96.99 67.94,98.26 64.13,98.26 63.5,97.62 62.23,97.62 IC11.3 60.32,96.99 56.51,96.99 55.24,98.26 51.43,98.26 50.8,97.62 49.53,97.62 IC10.3 47.62,96.99 43.81,96.99 42.54,98.26 38.73,98.26 38.1,97.62 36.83,97.62 IC8.3 34.92,96.99 31.11,96.99 29.84,98.26 26.03,98.26 25.39,97.62 24.12,97.62 IC7.3 22.22,96.99 18.41,96.99 17.14,98.26 13.33,98.26 12.7,97.62 11.43,97.62 IC6.3 | v14.6,80.48 v9.52,80.48
PIA-A1
  Top 0.254: 76.19,83.66 73.66,81.11 73.66,78.58 72.38,77.3 IC25.17 | 76.19,83.66 76.19,97.62 74.92,98.89 IC12.4 | 76.19,83.66 76.19,80.48 75.56,79.84 75.56,77.94 76.83,76.67 76.83,75.4 76.19,74.77 76.19,67.78 70.48,67.78 69.84,67.14 69.84,62.7 67.94,60.8 67.94,60.16 68.57,59.52 68.57,31.58 67.3,30.31 IC16.5
  Bottom 0.254: IC16.5 65.4,29.68 64.77,29.68 63.5,28.41 56.51,28.41 55.24,29.68 IC15.5 52.7,29.68 52.07,29.04 50.8,29.04 50.16,28.41 43.81,28.41 42.54,29.68 IC9.5 40,29.68 39.37,29.68 38.1,28.41 31.11,28.41 29.84,29.68 IC4.5 27.3,29.68 26.66,29.68 25.39,28.41 18.41,28.41 17.14,29.68 IC3.5 14.6,29.68 13.97,29.68 12.7,28.41 5.71,28.41 4.44,29.68 IC2.5 | 20.95,100.8 14.6,100.8 13.97,100.16 12.7,100.16 12.06,99.53 IC6.4 | 20.95,100.8 22.22,99.53 IC7.4 | 33.65,100.8 34.92,99.53 IC8.4 | 33.65,100.8 20.95,100.8 | 33.65,100.8 42.54,100.8 43.81,99.53 47.62,99.53 IC10.4 50.16,99.53 50.8,100.16 52.07,100.16 52.7,100.8 55.24,100.8 56.51,99.53 60.32,99.53 IC11.4 62.86,99.53 64.13,99.53 65.4,100.8 71.75,100.8 | 71.75,100.8 73.02,99.53 IC12.4 | 71.75,100.8 80.64,100.8 81.91,99.53 85.72,99.53 IC13.4 88.26,99.53 88.89,99.53 90.16,100.8 93.34,100.8 94.61,99.53 98.42,99.53 IC14.4
PIA-A2  (via drill 0.61)
  Top 0.254: v83.18,72.86 83.18,94.45 81.91,95.72 v81.91,107.15 | v57.78,25.87 57.78,55.08 60.32,57.62 60.32,70.95 v59.69,71.59
  Bottom 0.254: 57.78,26.5 59.69,26.5 60.32,25.87 62.86,25.87 63.5,26.5 64.13,26.5 64.77,27.14 65.4,27.14 IC16.6 | 57.78,26.5 54.61,26.5 IC15.6 53.34,26.5 50.8,26.5 50.16,25.87 47.62,25.87 46.98,26.5 41.91,26.5 IC9.6 40,27.14 39.37,27.14 38.73,26.5 38.1,26.5 37.46,25.87 34.92,25.87 34.29,26.5 29.2,26.5 IC4.6 27.3,27.14 26.66,27.14 26.03,26.5 25.39,26.5 24.76,25.87 22.22,25.87 21.58,26.5 16.5,26.5 IC3.6 14.6,27.14 13.97,27.14 13.33,26.5 12.7,26.5 12.06,25.87 4.44,25.87 3.8,26.5 IC2.6 | IC6.7 11.43,107.78 12.7,107.78 13.33,108.42 17.14,108.42 17.77,107.78 22.86,107.78 IC7.7 24.12,107.78 25.39,107.78 26.03,108.42 29.84,108.42 30.47,107.78 35.55,107.78 IC8.7 36.83,107.78 38.1,107.78 38.73,108.42 42.54,108.42 43.18,107.78 48.26,107.78 IC10.7 49.53,107.78 50.8,107.78 51.43,108.42 55.24,108.42 55.88,107.78 60.96,107.78 IC11.7 62.23,107.78 63.5,107.78 64.13,108.42 67.94,108.42 68.57,107.78 73.66,107.78 IC12.7 74.92,107.78 76.19,107.78 76.83,108.42 80.64,108.42 v81.91,107.15 85.72,107.15 IC13.7 87.62,107.78 88.89,107.78 89.53,108.42 93.34,108.42 94.61,107.15 98.42,107.15 IC14.7 | v83.18,72.86 78.1,72.86 77.46,73.5 72.38,73.5 IC25.16 70.48,74.13 68.57,74.13 67.3,72.86 62.86,72.86 61.59,71.59 v59.69,71.59 | 57.78,26.5 v57.78,25.87
PIA-A3  (via drill 0.61)
  Top 0.254: v77.46,70.32 77.46,77.3 78.1,77.94 77.46,78.58 77.46,100.16 76.19,101.44 76.19,102.7 75.56,103.34 76.19,103.97 76.19,109.05 75.56,109.69 IC12.8 | v12.7,76.67 v12.7,84.92 12.7,92.55 12.06,93.18 12.7,93.81 12.7,109.05 12.06,109.69 IC6.8 | v17.77,76.67 17.14,76.03 17.14,42.38 18.41,41.11 18.41,25.87 17.77,25.23 17.77,21.42 17.14,20.79 17.14,19.52 IC3.9 | v33.65,85.56 v33.65,109.69 | v68.57,71.59 67.94,72.22 67.94,84.92 67.3,85.56 67.3,86.19 v67.94,86.83
  Bottom 0.254: IC11.8 62.86,109.69 64.13,109.69 65.4,110.96 67.94,110.96 69.21,109.69 73.02,109.69 IC12.8 75.56,109.69 76.83,109.69 78.1,110.96 80.64,110.96 81.91,109.69 85.72,109.69 IC13.8 88.26,109.69 89.53,109.69 90.8,110.96 93.34,110.96 93.97,110.33 99.05,110.33 IC14.8 | v77.46,70.32 76.83,70.95 72.38,70.95 IC25.15 70.48,71.59 v68.57,71.59 | IC16.9 65.4,19.52 64.77,19.52 64.13,18.88 63.5,18.88 62.86,18.25 60.32,18.25 59.69,18.88 54.61,18.88 IC15.9 53.34,18.88 50.8,18.88 50.16,18.25 47.62,18.25 46.98,18.88 41.91,18.88 IC9.9 40,19.52 39.37,19.52 38.73,18.88 38.1,18.88 37.46,18.25 34.92,18.25 34.29,18.88 29.2,18.88 IC4.9 27.3,19.52 26.66,19.52 26.03,18.88 25.39,18.88 24.76,18.25 22.22,18.25 21.58,18.88 16.5,18.88 IC3.9 14.6,19.52 13.97,19.52 13.33,18.88 12.7,18.88 12.06,18.25 4.44,18.25 3.8,18.88 IC2.9 | IC10.8 47.62,109.69 43.81,109.69 42.54,110.96 37.46,110.96 36.83,110.33 IC8.8 34.92,109.69 v33.65,109.69 | IC6.8 11.43,110.33 12.06,110.96 17.14,110.96 18.41,109.69 22.22,109.69 IC7.8 | v17.77,76.67 v12.7,76.67 | v12.7,84.92 33.02,84.92 v33.65,85.56 34.92,86.83 38.1,86.83 38.73,86.19 51.43,86.19 52.7,87.47 67.3,87.47 v67.94,86.83
PIA-A4  (via drill 0.61)
  Top 0.254: IC14.13 90.8,109.69 90.16,109.05 90.16,95.72 93.34,95.72 93.97,95.08 93.97,88.73 92.7,87.47 v92.7,67.78 92.7,41.74 v92.07,41.11 | v81.27,23.33 81.91,23.96 81.91,32.85 81.27,33.49 81.27,40.48 v81.91,41.11
  Bottom 0.254: IC2.12 12.06,19.52 12.7,19.52 13.97,20.79 17.14,20.79 18.41,19.52 22.22,19.52 IC3.12 24.76,19.52 25.39,19.52 26.66,20.79 29.84,20.79 31.11,19.52 34.92,19.52 IC4.12 37.46,19.52 38.1,19.52 39.37,20.79 42.54,20.79 43.81,19.52 47.62,19.52 IC9.12 50.16,19.52 50.8,19.52 52.07,20.79 55.24,20.79 56.51,19.52 60.32,19.52 IC15.12 62.86,19.52 63.5,19.52 64.77,20.79 | 64.77,20.79 67.94,20.79 69.21,19.52 73.02,19.52 IC16.12 | IC6.13 4.44,109.69 6.34,109.69 7.62,108.42 12.06,108.42 12.7,109.05 15.24,109.05 IC7.13 16.5,109.05 17.77,109.05 18.41,108.42 24.76,108.42 25.39,109.05 27.93,109.05 IC8.13 29.2,109.05 30.47,109.05 31.11,108.42 37.46,108.42 38.1,109.05 40.64,109.05 IC10.13 41.91,109.05 43.18,109.05 43.81,108.42 50.16,108.42 50.8,109.05 53.34,109.05 IC11.13 54.61,109.05 55.88,109.05 56.51,108.42 62.86,108.42 63.5,109.05 66.03,109.05 IC12.13 67.3,109.05 68.57,109.05 69.21,108.42 75.56,108.42 76.19,109.05 78.73,109.05 IC13.13 80,109.05 81.27,109.05 81.91,108.42 88.26,108.42 88.89,109.05 91.44,109.05 IC14.13 | v92.7,67.78 78.1,67.78 77.46,68.41 72.38,68.41 IC25.14 | 64.77,20.79 64.77,23.33 67.94,23.33 68.57,23.96 69.84,23.96 70.48,23.33 v81.27,23.33 | v81.91,41.11 v92.07,41.11
PIA-A5  (via drill 0.61)
  Top 0.254: v67.3,61.43 66.67,60.8 66.67,58.89 64.13,56.35 64.13,28.41 62.86,27.14 IC15.15 | v85.08,100.8 85.08,98.26 84.45,97.62 84.45,74.13 85.08,73.5 85.08,65.88 v85.72,65.24
  Bottom 0.254: 14.6,105.88 15.24,106.52 IC7.14 | 14.6,105.88 7.62,105.88 6.34,107.15 4.44,107.15 IC6.14 | 27.3,105.88 27.93,106.52 IC8.14 | 27.3,105.88 14.6,105.88 | 40,105.88 40.64,106.52 IC10.14 | 40,105.88 27.3,105.88 | 52.7,105.88 53.34,106.52 IC11.14 | 52.7,105.88 40,105.88 | 65.4,105.88 66.03,106.52 IC12.14 | 65.4,105.88 52.7,105.88 | 78.1,105.88 78.73,106.52 IC13.14 | 78.1,105.88 65.4,105.88 | 88.89,105.88 78.1,105.88 | 88.89,105.88 90.8,105.88 91.44,106.52 IC14.14 | IC2.15 12.06,27.14 12.7,27.14 13.97,28.41 17.14,28.41 18.41,27.14 22.22,27.14 IC3.15 24.76,27.14 25.39,27.14 26.66,28.41 29.84,28.41 31.11,27.14 34.92,27.14 IC4.15 37.46,27.14 38.1,27.14 39.37,28.41 42.54,28.41 43.81,27.14 47.62,27.14 IC9.15 50.16,27.14 50.8,27.14 52.07,28.41 55.24,28.41 56.51,27.14 60.32,27.14 IC15.15 62.86,27.14 63.5,27.14 64.77,28.41 67.94,28.41 69.21,27.14 73.02,27.14 IC16.15 | v67.3,61.43 66.03,62.7 62.23,62.7 62.23,64.61 62.86,65.24 65.4,65.24 66.03,65.88 67.94,65.88 68.57,66.51 70.48,66.51 IC25.13 72.38,65.88 77.46,65.88 78.1,65.24 v85.72,65.24 | 88.89,105.88 88.89,100.8 v85.08,100.8
PIA-A6  (via drill 0.61)
  Top 0.254: v84.45,62.7 84.45,72.86 83.81,73.5 v83.81,98.26 | v69.21,29.68 69.84,30.31 69.84,44.28 69.21,44.92 v69.21,60.16
  Bottom 0.254: IC2.16 12.06,29.68 12.7,29.68 13.97,30.95 17.14,30.95 18.41,29.68 22.22,29.68 IC3.16 24.76,29.68 25.39,29.68 26.66,30.95 29.84,30.95 31.11,29.68 34.92,29.68 IC4.16 37.46,29.68 38.1,29.68 39.37,30.95 42.54,30.95 43.81,29.68 47.62,29.68 IC9.16 50.16,29.68 50.8,29.68 52.07,30.95 55.24,30.95 56.51,29.68 60.32,29.68 IC15.16 62.86,29.68 63.5,29.68 64.77,30.95 67.94,30.95 v69.21,29.68 73.02,29.68 IC16.16 | IC6.17 4.44,99.53 6.34,99.53 7.62,98.26 12.06,98.26 12.7,98.89 15.24,98.89 IC7.17 16.5,98.89 17.77,98.89 18.41,98.26 24.76,98.26 25.39,98.89 27.93,98.89 IC8.17 29.2,98.89 30.47,98.89 31.11,98.26 37.46,98.26 38.1,98.89 40.64,98.89 IC10.17 41.91,98.89 43.18,98.89 43.81,98.26 50.16,98.26 50.8,98.89 53.34,98.89 IC11.17 54.61,98.89 55.88,98.89 56.51,98.26 62.86,98.26 63.5,98.89 66.03,98.89 IC12.17 67.3,98.89 68.57,98.89 69.21,98.26 75.56,98.26 76.19,98.89 78.73,98.89 IC13.17 80,98.89 81.27,98.89 81.91,98.26 v83.81,98.26 88.26,98.26 88.89,98.89 91.44,98.89 IC14.17 | 74.29,63.34 77.46,63.34 78.1,62.7 v84.45,62.7 | 74.29,63.34 72.38,63.34 IC25.12 | v69.21,60.16 73.02,60.16 74.29,61.43 74.29,63.34
PIA-A7  (via drill 0.61)
  Top 0.254: v71.75,37.3 71.75,60.8 IC25.11 73.02,61.43 73.66,60.8 75.56,62.7 80.64,62.7 81.27,63.34 81.27,70.95 v81.91,71.59 | v95.24,93.18 94.61,93.81 94.61,95.72 93.34,96.99 IC14.18 | v109.21,93.18 109.85,92.55 109.85,83.66 109.21,83.02 109.21,73.5 v109.85,72.86 | v6.98,96.99 7.62,96.36 7.62,78.58 6.98,77.94 7.62,77.3 7.62,69.69 8.25,69.05 8.25,55.71 8.89,55.08 8.89,37.94 9.52,37.3 IC2.19
  Bottom 0.254: IC12.18 65.4,96.99 64.77,96.99 63.5,95.72 60.32,95.72 59.69,96.36 54.61,96.36 IC11.18 53.34,96.36 52.7,95.72 47.62,95.72 46.98,96.36 41.91,96.36 IC10.18 40,96.99 38.73,96.99 37.46,95.72 34.92,95.72 34.29,96.36 29.2,96.36 IC8.18 27.3,96.99 26.03,96.99 24.76,95.72 22.22,95.72 21.58,96.36 16.5,96.36 IC7.18 14.6,96.99 13.33,96.99 12.06,95.72 9.52,95.72 8.25,96.99 v6.98,96.99 4.44,96.99 IC6.18 | IC13.18 80,96.36 85.08,96.36 85.72,95.72 88.26,95.72 88.89,96.36 89.53,96.36 90.16,96.99 90.8,96.99 IC14.18 | IC2.19 11.43,37.94 13.97,37.94 14.6,38.57 17.14,38.57 17.77,37.94 20.31,37.94 20.95,37.3 22.22,37.3 IC3.19 24.12,37.94 26.66,37.94 27.3,38.57 29.84,38.57 30.47,37.94 33.02,37.94 33.65,37.3 34.92,37.3 IC4.19 36.83,37.94 39.37,37.94 40,38.57 45.08,38.57 46.35,37.3 47.62,37.3 IC9.19 49.53,37.94 50.16,38.57 55.24,38.57 55.88,37.94 57.15,37.94 57.78,37.3 60.32,37.3 IC15.19 62.86,37.3 64.13,37.3 65.4,38.57 67.94,38.57 69.21,37.3 v71.75,37.3 73.02,37.3 IC16.19 | v109.21,93.18 v95.24,93.18 | v109.85,72.86 84.45,72.86 83.18,71.59 v81.91,71.59
PIA-B0
  Bottom 0.254: 38.73,80.48 23.49,80.48 22.22,79.21 IC5.23 | 38.73,80.48 40,79.21 IC1.23 | 38.73,80.48 51.43,80.48 55.24,76.67 IC26.18
PIA-B1
  Bottom 0.254: 38.73,77.94 23.49,77.94 22.22,76.67 IC5.22 | 38.73,77.94 40,76.67 IC1.22 | 38.73,77.94 51.43,77.94 55.24,74.13 IC26.17
PIA-B2
  Bottom 0.254: IC5.21 22.22,74.13 23.49,75.4 38.73,75.4 40,74.13 IC1.21 42.54,74.13 43.81,72.86 53.97,72.86 55.24,71.59 IC26.16
PIA-B3
  Bottom 0.254: IC5.20 22.22,71.59 23.49,72.86 38.73,72.86 40,71.59 IC1.20 42.54,71.59 43.81,70.32 53.97,70.32 55.24,69.05 IC26.15
PIA-B4
  Bottom 0.254: IC5.18 22.22,66.51 23.49,67.78 51.43,67.78 52.7,66.51 55.24,66.51 IC26.14
PIA-B5
  Bottom 0.254: IC1.18 42.54,66.51 43.81,65.24 51.43,65.24 52.7,63.97 55.24,63.97 IC26.13
R/W\  (via drill 0.61)
  Top 0.254: v116.2,34.76 116.2,43.65 IC21.13 | v140.97,44.92 140.97,68.41 141.6,69.05 IC17.34 | v135.88,121.12 135.88,102.07 135.25,101.44 135.25,94.45 133.98,93.18 133.98,69.69 v134.62,69.05
  Bottom 0.254: v116.2,34.76 109.85,34.76 109.21,34.12 96.52,34.12 95.24,35.39 IC24.21 | v140.97,44.92 122.55,44.92 121.28,43.65 118.74,43.65 IC21.13 | v135.88,121.12 123.82,121.12 123.19,120.48 IC22.27 | v134.62,69.05 141.6,69.05 IC17.34
RST\  (via drill 0.61)
  Top 0.254: IC17.40 144.14,84.29 144.78,83.66 144.78,47.46 145.41,46.82 145.41,40.48 146.04,39.84 146.04,27.14 147.31,25.87 147.31,11.27 146.68,10.63 IC18.6 144.14,10.63 143.5,10 143.5,6.82 144.14,6.18 v144.14,3.01 | v99.05,69.05 99.69,68.41 99.69,46.19 100.32,45.55 100.32,37.3 103.5,34.12 103.5,27.77 100.32,24.6 100.32,11.9 101.59,10.63 v101.59,2.38
  Bottom 0.254: v99.05,69.05 95.88,69.05 IC24.34 | v101.59,2.38 102.23,1.74 142.87,1.74 v144.14,3.01
RX  (via drill 0.61)
  Top 0.254: v112.39,67.78 112.39,39.84 IC20.12
  Bottom 0.254: v112.39,67.78 111.75,68.41 102.86,68.41 IC21.2
RXD  (via drill 0.61)
  Top 0.254: v109.85,33.49 109.85,37.3 IC20.13 | v95.24,33.49 95.24,25.23 94.61,24.6 94.61,21.42 X1.2
  Bottom 0.254: v95.24,33.49 v109.85,33.49
TX  (via drill 0.61)
  Top 0.254: v114.93,57.62 114.93,39.84 IC20.11
  Bottom 0.254: v114.93,57.62 114.3,58.25 102.86,58.25 IC21.6
TXD  (via drill 0.61)
  Top 0.254: v92.07,37.3 92.07,21.42 X1.3
  Bottom 0.254: v92.07,37.3 100.32,37.3 100.96,36.66 106.04,36.66 106.67,37.3 107.31,37.3 IC20.14
VCC  (via drill 0.61)  (1 unrouted)
  Top 0.508: IC23.27 142.87,120.48 142.87,121.75 IC23.28 | v155.57,50 155.57,59.52 R7.2 | IC19.16 156.84,46.19 v156.84,48.73 158.11,48.73 158.11,71.59 | 158.11,71.59 158.11,95.08 155.57,97.62 155.57,103.34 v154.3,104.61 153.66,105.25 153.66,116.67 v154.3,117.31 v154.3,119.85 | v76.19,36.03 76.19,39.2 75.56,39.84 IC16.20 | v12.06,13.81 12.06,16.98 IC2.11 | v23.49,14.44 23.49,16.34 IC3.11 | v36.19,14.44 36.19,16.34 IC4.11 | v48.89,14.44 48.89,16.34 IC9.11 | v61.59,14.44 61.59,16.34 IC15.11 | v74.29,14.44 74.29,16.34 IC16.11 | v53.97,81.75 53.97,91.28 IC11.20 | IC1.24 41.27,82.39 41.27,91.28 IC10.20 | v15.87,81.75 v15.87,89.37 15.87,91.28 IC7.20 | v3.17,89.37 3.17,91.28 IC6.20 | v28.57,89.37 28.57,91.28 IC8.20 | R2.2 135.25,21.42 135.25,22.7 R1.2 135.25,23.96 v135.25,27.14 | v153.03,27.14 153.03,23.96 IC18.14 | v120.01,8.09 v120.01,15.71 119.38,16.34 119.38,25.23 v120.01,25.87 | v125.09,15.71 125.09,13.81 R12.2 | IC17.35 142.87,72.22 142.87,73.5 IC17.36 | R6.2 117.47,74.77 117.47,78.58 R8.2 117.47,79.84 117.47,81.11 R5.2 | v120.01,65.24 v120.01,74.13 | v139.06,71.59 138.42,70.95 v138.42,65.24 | v97.15,38.57 97.15,29.04 C10.1 97.15,27.77 v97.15,24.6 | 104.13,48.09 103.5,48.73 IC21.10 | 104.13,48.09 104.13,44.28 103.5,43.65 IC21.12 102.23,43.02 102.23,39.84 IC20.16 | 104.13,53.17 103.5,53.81 IC21.8 | 104.13,53.17 104.13,48.09 | v66.67,84.29 66.67,91.28 IC12.20 | v79.37,89.37 79.37,91.28 IC13.20 | v73.02,89.37 73.02,84.29 IC25.20 | v92.07,88.1 92.07,91.28 IC14.20 | v104.77,88.1 104.77,84.92 S2.A1 104.77,83.66 104.77,83.02 103.5,81.75 103.5,78.58 S2.A 103.5,77.3 103.5,73.5 104.13,72.86 104.13,53.17
  Top 0.508: 108.58,17.61 v109.85,17.61 | v108.58,23.33 108.58,17.61 | v86.99,16.34 86.99,10 v87.62,9.36 | 108.58,17.61 v108.58,9.36 | 158.11,71.59 v157.47,71.59
  Bottom 0.508: IC22.1 108.58,122.39 121.28,122.39 IC22.28 123.82,122.39 126.36,122.39 IC23.1 128.9,122.39 141.6,122.39 IC23.28 | v156.84,48.73 v155.57,50 | v154.3,104.61 151.76,104.61 IC28.6 | v154.3,117.31 156.84,117.31 IC28.16 | v154.3,119.85 144.14,119.85 IC23.27 | v76.19,36.03 78.1,36.03 IC24.20 80.64,36.03 87.62,36.03 90.16,38.57 93.34,38.57 IC24.22 95.88,38.57 v97.15,38.57 101.59,38.57 IC20.16 | 22.22,41.11 12.06,41.11 11.43,40.48 IC2.20 | 22.22,41.11 22.86,40.48 IC3.20 | 34.92,41.11 35.55,40.48 IC4.20 | 34.92,41.11 22.22,41.11 | 34.92,41.11 42.54,41.11 43.81,39.84 47.62,39.84 IC9.20 49.53,40.48 50.16,41.11 60.32,41.11 | 60.32,41.11 60.96,40.48 IC15.20 | 60.32,41.11 73.02,41.11 73.66,40.48 IC16.20 | v12.06,13.81 12.06,14.44 17.77,14.44 19.04,13.17 20.31,13.17 21.58,14.44 v23.49,14.44 v36.19,14.44 v48.89,14.44 v61.59,14.44 v74.29,14.44 | v53.97,81.75 55.24,81.75 IC26.20 | v15.87,81.75 19.68,81.75 IC5.24 | v3.17,89.37 v15.87,89.37 v28.57,89.37 | IC8.20 29.84,91.91 31.11,91.91 32.38,93.18 37.46,93.18 38.73,91.91 40,91.91 IC10.20 42.54,91.91 43.81,91.91 45.08,93.18 50.16,93.18 51.43,91.91 52.7,91.91 IC11.20 55.24,91.91 55.88,91.91 57.15,93.18 62.86,93.18 64.13,91.91 65.4,91.91 IC12.20 | v153.03,27.14 v135.25,27.14 127.63,27.14 126.36,25.87 123.82,25.87 IC27.14 121.28,25.87 v120.01,25.87 | R12.2 125.72,13.17 126.99,13.17 R3.2 | v120.01,8.09 121.91,8.09 R9.2 | v125.09,15.71 123.82,15.71 IC27.10 121.28,15.71 v120.01,15.71 117.47,15.71 115.56,17.61 IC27.4 113.66,18.25 111.12,18.25 110.48,17.61 v109.85,17.61 | v120.01,65.24 120.64,65.88 126.99,65.88 IC17.8 128.27,65.88 137.79,65.88 v138.42,65.24
  Bottom 0.508: v120.01,74.13 118.1,74.13 R6.2 | v139.06,71.59 141.6,71.59 IC17.35 144.14,71.59 v157.47,71.59 | IC24.24 95.88,43.65 100.96,43.65 IC21.12 | v66.67,84.29 70.48,84.29 IC25.20 | v79.37,89.37 v73.02,89.37 | v104.77,88.1 v92.07,88.1 | IC13.20 80.64,91.91 82.55,91.91 83.81,90.64 90.8,90.64 91.44,91.28 IC14.20 | R8.2 117.47,78.58 116.2,77.3 103.5,77.3 S2.A | v108.58,23.33 107.94,23.33 107.31,23.96 97.78,23.96 v97.15,24.6 | v86.99,16.34 78.1,16.34 77.46,16.98 75.56,16.98 IC16.11 | v108.58,9.36 v87.62,9.36
VMA  (via drill 0.61)
  Top 0.254: v156.84,10.63 156.84,16.34 157.47,16.98 157.47,24.6 156.2,25.87 156.2,26.5 157.47,27.77 v157.47,29.68 | v151.12,29.68 151.76,29.68 151.76,41.11 150.49,42.38 150.49,49.37 151.12,50 v151.12,72.86
  Bottom 0.254: v156.84,10.63 154.3,10.63 IC18.9 | v157.47,29.68 v151.12,29.68 | v151.12,72.86 141.6,72.86 139.69,74.77 128.27,74.77 IC17.5